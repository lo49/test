<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>drivers</name>
    <file>
      <name>$PROJ_DIR$\drivers\enc28j60.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\horloge.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\initCC1110.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\drivers\spi.c</name>
    </file>
  </group>
  <group>
    <name>sys</name>
    <file>
      <name>$PROJ_DIR$\sys\ip_arp_udp_tcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sys\paquet.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sys\tcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sys\udp.c</name>
    </file>
  </group>
</project>


