# IAR project collecteur_victoria.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC1110F32 CC1110F32
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: C:\Users\lucie\Documents\GitHub\test; C:\Users\lucie\Documents\GitHub\test\sys; C:\Users\lucie\Documents\GitHub\test\drivers
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  A8051.ADefines: NDEBUG
  group drivers
    drivers/: enc28j60.c horloge.c initCC1110.c spi.c
  group sys
    sys/: ip_arp_udp_tcp.c paquet.c tcp.c udp.c
